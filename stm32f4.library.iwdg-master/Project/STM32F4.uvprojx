# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F407ZG (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Driver;..\Libraries\inc;..\System;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../Doc/: readme.txt
  group Core
    ../Core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_iwdg.c
  group System
    ../System/: explore_system.c explore_systick.c explore_usart.c
  group Driver
    ../Driver/: driver_led.c driver_exti.c driver_iwdg.c
  group User
    ../User/: stm32f4xx_main.c stm32f4xx_conf.h stm32f4xx_it.c
