# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F407ZG (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FatFs;..\Libraries;..\Startup;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../: readme.txt
  group Startup
    ../Startup/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Library
    ../Libraries/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_spi.c
  group FatFs
    ../FatFs/: ffconf.h diskio.c ff.c cc936.c
  group User
    ../User/: stm32f4xx_conf.h stm32f4xx_main.c stm32f4xx_it.c bsp_systick.c bsp_usart.c bsp_led.c bsp_lcd.c bsp_key.c bsp_spi.c bsp_w25qxx.c
